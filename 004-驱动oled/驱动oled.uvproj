# Keil uVision project 驱动oled.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 驱动oled +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c oled.c codetab.c my_IIC.c my_IIC.h

# Keil uVision project 驱动mpu6050.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 驱动mpu6050 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c oled.c oled.h my_IIC2.c my_IIC2.h my_IIC.c my_IIC.h mpu6050.c mpu6050.h codetab.c codetab.h STARTUP.A51
